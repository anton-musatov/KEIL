# Keil uVision project UART.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.0.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Clock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\PACK\ArteryTek\AT32F413_DFP\2.0.4\Device\Firmware\Peripherals\inc;.\Inc;.\Src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./Src/: GPIO.c main.c ClockInit.c DMA.c UART.c
  group Inc
    ./Inc/: GPIO.h ClockInit.h UART.h DMA.h
software components: CMSIS:CORE 5.6.0, Device:at32f413_conf 2.0.0, Device:at32f413_firmware_library:crm 2.0.0, Device:at32f413_firmware_library:misc 2.0.0, Device:startup 2.0.0
